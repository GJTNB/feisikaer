# IAR project vcan_Kinetis.ewp, settings and files
configuration FN15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; ..\..\USER\inc; ..\..\USER\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FN15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.srec
configuration FX15_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60X512.icf
configuration FX15_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  group App
    ../../App/: main.c MK60_conf.c MK60_it.c
    ../../App/Inc/: MK60_conf.h MK60_it.h PORT_cfg.h
  group Board
    ../../USER/src/: scope.c
    ../../Board/src/: VCAN_camera.c vcan_img2sd.c VCAN_key.c VCAN_LED.C VCAN_NRF24L0.c VCAN_OV7725_Eagle.c VCAN_SCCB.c
    ../../Board/inc/: VCAN_OV7725_REG.h
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group LIB/USB
    ../../Lib/USB/: USB.c USB_CDC.c
  group USER/debug
    ../../USER/src/: button.c ui_debug.c ui_debug_common.c ui_setpage.c
    ../../USER/inc/: button.h ui_debug.h ui_debug_common.h ui_setpage.h
  group USER/flash
    ../../USER/src/: flash_param.c
    ../../USER/inc/: flash_param.h
  group USER/global_var
    ../../USER/src/: global_var.c
    ../../USER/inc/: global_var.h
  group USER/infrared
    ../../USER/src/: infrared.c
    ../../USER/inc/: infrared.h
  group USER/init
    ../../USER/src/: init.c
    ../../USER/inc/: init.h
  group USER/isr
    ../../USER/src/: isr.c
    ../../USER/inc/: isr.h
  group USER/motor_control
    ../../USER/src/: speed_control.c
    ../../USER/inc/: speed_control.h
  group USER/mpu6050
    ../../USER/src/: get_car_angle.c mpu6050.c mpuiic.c
    ../../USER/inc/: mpu6050.h mpuiic.h
  group USER/oled
    ../../USER/src/: bsp_my_oled.c bsp_oled.c
    ../../USER/inc/: bsp_my_oled.h bsp_oled.h
  group USER/picture_deal
    ../../USER/src/: picture_deal.c
    ../../USER/inc/: picture_deal.h
  group USER/steer_control
    ../../USER/src/: steer_control.c
    ../../USER/inc/: steer_control.h
